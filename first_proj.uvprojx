# Keil uVision project first_proj.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: first_proj
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User Application
    ./: main.c
  group Drivers
    ./: HAL_GPIO.c HAL_GPIO.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
